*Third order low pass filter, butterworth, https://en.wikipedia.org/wiki/Butterworth_filter

V1 vin 0 SIN (0, 1, 1k)
L1 vin n1 238.8m
C1 n1 0 212.3n
L2 n1 vout 79.60m
R1 vout 0 1k
